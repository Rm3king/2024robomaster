# Keil uVision project robo_template.uvprojx, settings and files
target robo_template (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: robo_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,DEBUG_MODE,TEMPLATE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Libraries/Scheduler;../Libraries/Helper;../Libraries/InertialSensor;../Libraries/Math;../Libraries/Param;../Libraries/AHRS;../Libraries/RCProtocol;../Libraries/RefereeSystem;../Libraries/PID;../Libraries/Motor;../Libraries/CanDevice;../Libraries/Message;../Modules/Types;../Libraries/Error;../Modules/Common/CAN;../Modules/RoboMaster/Core;../Modules/Vehicles/Template/Referee;../Modules/RoboMaster/Motor;../Modules/Common/PID;../Libraries/UART;../Vehicles/MW_infantry/task
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/AHRS
    ../Libraries/AHRS/: AHRS.cpp MahonyAHRS.cpp
  group Libraries/CanDevice
    ../Libraries/CanDevice/: CanDevice.cpp
  group Libraries/Error
    ../Libraries/Error/: Error.cpp
  group Libraries/Helper
    ../Libraries/Helper/: Helper.cpp
  group Libraries/InertialSensor
    ../Libraries/InertialSensor/: InertialSensor.cpp InertialSensor_BMI088.cpp InertialSensor_Backend.cpp
  group Libraries/Math
    ../Libraries/Math/: CommonMath.cpp CmsisCompatibility.cpp Filters.cpp Matrix3.cpp Quaternion.cpp Rotation.cpp Translation.cpp Vector2.cpp Vector3.cpp
  group Libraries/Motor
    ../Libraries/Motor/: Motor.cpp Motor_RM.cpp Motor_Backend.cpp
  group Libraries/Param
    ../Libraries/Param/: Flash.cpp
  group Libraries/PID
    ../Libraries/PID/: PID_Controller.cpp
  group Libraries/RCProtocol
    ../Libraries/RCProtocol/: RCProtocol.cpp RCProtocol_Backend.cpp RCProtocol_DBUS.cpp
  group Libraries/RefereeSystem
    ../Libraries/RefereeSystem/: RefereeSystem_Data.cpp
  group Libraries/Scheduler
    ../Libraries/Scheduler/: Task.cpp Scheduler.cpp Scheduler_Common.cpp
  group Libraries/UART
    ../Libraries/UART/: UARTDriver.cpp
  group Modules/Common/PID
    ../Modules/Common/PID/: PIDControlTask.cpp
  group Modules/Commonr/CAN
    ../Modules/Common/CAN/: CANSendTask.cpp
  group Modules/RoboMaster/Core
    ../Modules/RoboMaster/Core/: AttitudeSolutionTask.cpp LEDControlTask.cpp SongPlayerTask.cpp
  group Modules/RoboMaster/Motor
    ../Modules/RoboMaster/Motor/: Motor_RM_Tasks.cpp
  group Vehicles\MW_infantry\task
    ../Vehicles/MW_infantry/task/Ammo/: AmmoControlTask.cpp AmmoControlTask.h
    ../Vehicles/MW_infantry/task/Chassis/: ChassisControlTask.cpp ChassisControlTask.h
    ../Vehicles/MW_infantry/task/Control/: ComputerVisionControlTask.cpp MainControlTask.cpp ComputerVisionControlTask.h MainControlTask.h GimbalConstantAimShootCommand.h IMUData.h OffboardLink.h ReferenceDataMini.h LockTargetSuggest.h
    ../Vehicles/MW_infantry/task/Gimbal/: GimbalControlTask.cpp GimbalControlTask.h
    ../Vehicles/MW_infantry/task/Referee/: RefereeSystemTask.cpp RefereeSystemTask.h
    ../Vehicles/MW_infantry/task/Remote/: RemoteControlTask.cpp RemoteControlTask.h
    ../Vehicles/MW_infantry/task/Robot/: Params.cpp Robot.cpp Params.h Robot.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
